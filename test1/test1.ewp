# IAR project test1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x Milandr 1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $EW_DIR$\common\_MDR32F9Qx\inc; $EW_DIR$\arm\CMSIS\Include; $EW_DIR$\arm\CMSIS\Device\Milandr\MDR32F9Qx\inc; _Config; _MCU_drv
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: test1.srec
  ILINK.IlinkOutputFile: test1.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: test1.hex
  ILINK.IlinkIcfFile: _Config\MDR32F1.icf
  group (top)
    ./: main.cpp port.cpp port.h
  group Config
    _Config/: MDR32F1.icf MDR32F9Qx_board.h MDR32F9Qx_config.h
  group MCU_drv
    _MCU_drv/: MDR32F9Qx_it.c startup_MDR32F9Qx.s system_MDR32F9Qx.c system_MDR32F9Qx.h
    $EW_DIR$/common/_MDR32F9Qx/src/: MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c
